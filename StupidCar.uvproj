# Keil uVision project StupidCar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODAT2
  output: StupidCar +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware
  group Source Group 1
    ./: main.c
    ./Hardware/: Car.c Infrared.c Bluetooth.c
